options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: vhf_rx
    output_language: python
  states: {}

blocks:
- name: amp_enable
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,5,1,1
    label: TX Amp
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: band
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Band
    labels: '["Calib.", "50", "144", "222", "432", "903", "1296", "2304", "3456", "5760"]'
    num_opts: '0'
    options: '[cal_band, 50, 144, 222, 432, 903, 1296, 2304, 3456, 5760]'
    type: real
    value: cal_band
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: BB gain
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '62'
    value: '24'
  states: {}
- name: cal_band
  id: variable
  parameters:
    value: (cal_freq - 100e3) / 1e6
  states: {}
- name: cal_freq
  id: variable
  parameters:
    value: '626309441'
  states: {}
- name: correction
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: PPM
    orient: Qt.Horizontal
    start: '-20'
    step: '1'
    stop: '20'
    value: '0'
    widget: counter
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: IF gain
    orient: Qt.Horizontal
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: lna_enable
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,2,1,1
    label: LNA
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,4,1,3
    label: Tune (kHz)
    orient: Qt.Horizontal
    start: '80'
    step: '0.01'
    stop: '120'
    value: '100'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,6,1,1
    label: TX gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
  states: {}
- name: tx_text
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,4
    label: CW to send
    type: string
    value: ''
  states: {}
- name: audio_out
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '8000'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 4,0,1,7
    int_max: '0'
    int_min: '-120'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: cx_to_real
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: if_filter
  id: low_pass_filter
  parameters:
    cutoff_freq: '75000'
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '25000'
    win: firdes.WIN_HAMMING
  states: {}
- name: if_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '100000'
    fftsize: '1024'
    gui_hint: 3,0,1,7
    int_max: '0'
    int_min: '-120'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: interpolator
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    taps: ''
    type: fff
  states: {}
- name: mixer_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: mixer_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: offset_osc_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: offset_osc_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 100000 - tune * 1000 + 700
    offset: '0'
    phase: '0'
    samp_rate: samp_rate / decimation
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: rf_in
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: bb_gain
    bw0: '1750000'
    corr0: correction
    freq0: band * 1e6 + 100000 - offset
    gain0: 14 if lna_enable else 0
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: usb_filter
  id: band_pass_filter
  parameters:
    decim: '25'
    gain: '1'
    high_cutoff_freq: '2800'
    low_cutoff_freq: '200'
    samp_rate: samp_rate / decimation
    type: fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: volume_mult
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}

connections:
- [cx_to_real, '0', audio_waterfall, '0']
- [cx_to_real, '0', interpolator, '0']
- [if_filter, '0', if_waterfall, '0']
- [if_filter, '0', mixer_2, '1']
- [interpolator, '0', volume_mult, '0']
- [mixer_1, '0', if_filter, '0']
- [mixer_2, '0', usb_filter, '0']
- [offset_osc_1, '0', mixer_1, '1']
- [offset_osc_2, '0', mixer_2, '0']
- [rf_in, '0', mixer_1, '0']
- [usb_filter, '0', cx_to_real, '0']
- [volume_mult, '0', audio_out, '0']

metadata:
  file_format: 1
