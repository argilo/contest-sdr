options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: b200_rx
    output_language: python
  states: {}

blocks:
- name: band
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Band
    labels: '["Calib.", "50", "144", "222", "432", "903", "1296", "2304", "3400", "5760"]'
    num_opts: '0'
    options: '[cal_band, 50, 144, 222, 432, 903, 1296, 2304, 3400, 5760]'
    type: real
    value: cal_band
  states: {}
- name: cal_band
  id: variable
  parameters:
    value: (cal_freq - 100e3) / 1e6
  states: {}
- name: cal_freq
  id: variable
  parameters:
    value: '584309441'
  states: {}
- name: correction
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: PPM
    start: '-20'
    step: '0.1'
    stop: '20'
    value: '0'
    widget: counter
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: lp_taps_if
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '2800'
    low_cutoff_freq: '200'
    samp_rate: samp_rate / decimation
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: lp_taps_rf
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '75000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '25000'
    win: window.WIN_HAMMING
  states: {}
- name: offset
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,2
    label: RX gain
    start: '0'
    step: '2'
    stop: '76'
    value: '50'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,4,1,3
    label: Tune (kHz)
    start: '80'
    step: '0.01'
    stop: '120'
    value: '100'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,5,1,2
    label: TX gain
    start: '0'
    step: '1'
    stop: '89'
    value: '60'
  states: {}
- name: tx_text
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,4
    label: CW to send
    type: string
    value: ''
  states: {}
- name: audio_out
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '8000'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 4,0,1,4
    int_max: '0'
    int_min: '-120'
    showports: 'True'
    type: float
  states: {}
- name: cx_to_real
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: offset
    decim: decimation
    samp_rate: samp_rate
    taps: lp_taps_rf
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-100000 + tune * 1000 - 700'
    decim: '25'
    samp_rate: samp_rate / decimation
    taps: lp_taps_if
    type: ccc
  states: {}
- name: if_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '100000'
    fftsize: '2048'
    gui_hint: 3,0,1,7
    int_max: '0'
    int_min: '-120'
    showports: 'True'
    type: complex
  states: {}
- name: interpolator
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    taps: ''
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,4,1,3
    legend: 'False'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: (band * 1e6 + 100000 - offset) * (1 + correction*1e-6)
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: volume_mult
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}

connections:
- [cx_to_real, '0', audio_waterfall, '0']
- [cx_to_real, '0', interpolator, '0']
- [freq_xlating_fft_filter_ccc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', if_waterfall, '0']
- [freq_xlating_fir_filter_xxx_0, '0', cx_to_real, '0']
- [interpolator, '0', volume_mult, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [volume_mult, '0', audio_out, '0']
- [volume_mult, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
