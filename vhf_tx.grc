options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: vhf_tx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: samp_rate / interpolation
  states: {}
- name: band
  id: variable
  parameters:
    value: '432'
  states: {}
- name: correction
  id: variable
  parameters:
    value: '0'
  states: {}
- name: cw_vector
  id: variable
  parameters:
    value: (1,0,1,0,1,0,1,1,1, 0,0,0, 1,0,1,0,1,0,1,1,1, 0,0,0, 1,0,1,0,1,0,1,1,1, 0,0,0,0,0,0,0, 1,1,1,0,1,0,1, 0,0,0, 1, 0,0,0,0,0,0,0, 1,0,1,0,1,0,1,1,1, 0,0,0, 1, 0,0,0, 1,0,1,0,1,0,1,1,1,0,1,1,1, 0,0,0, 1,0,1, 0,0,0, 1,0,1,1,1,0,1, 0,0,0, 1,0,1,1,1,0,1, 0,0,0,0,0,0,0, 1,1,1, 0,0,0, 1, 0,0,0, 1,0,1,0,1, 0,0,0, 1,1,1, 0,0,0, 1,0,1, 0,0,0, 1,1,1,0,1, 0,0,0, 1,1,1,0,1,1,1,0,1, 0,0,0,0,0,0,0)
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '80'
  states: {}
- name: offset
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: tune
  id: variable
  parameters:
    value: '100'
  states: {}
- name: wpm
  id: variable
  parameters:
    value: '15'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.000001'
    type: complex
  states: {}
- name: click_filter
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '1e-2'
    type: complex
  states: {}
- name: cw_repeat
  id: blocks_repeat
  parameters:
    interp: int(1.2 * audio_rate / wpm)
    type: complex
  states: {}
- name: cw_vector_source
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: cw_vector
  states: {}
- name: mixer
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: offset_osc
  id: analog_sig_source_x
  parameters:
    amp: '0.9'
    freq: tune * 1000 + 100000
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: out
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    corr0: correction
    freq0: band * 1e6 + 100000 - offset
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: resamp
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: interpolation
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', resamp, '0']
- [click_filter, '0', blocks_add_const_vxx_0, '0']
- [cw_repeat, '0', click_filter, '0']
- [cw_vector_source, '0', cw_repeat, '0']
- [mixer, '0', out, '0']
- [offset_osc, '0', mixer, '0']
- [resamp, '0', mixer, '1']

metadata:
  file_format: 1
