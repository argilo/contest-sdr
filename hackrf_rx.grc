options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: hackrf_rx
    output_language: python
  states: {}

blocks:
- name: amp_enable
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,5,1,1
    label: TX Amp
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: band
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Band
    labels: '["Calib.", "50", "144", "222", "432", "903", "1296", "2304", "3400", "5760"]'
    num_opts: '0'
    options: '[cal_band, 50, 144, 222, 432, 903, 1296, 2304, 3400, 5760]'
    type: real
    value: cal_band
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,4,1,1
    label: BB gain
    start: '0'
    step: '2'
    stop: '62'
    value: '24'
  states: {}
- name: cal_band
  id: variable
  parameters:
    value: (cal_freq - 100e3) / 1e6
  states: {}
- name: cal_freq
  id: variable
  parameters:
    value: '584309441'
  states: {}
- name: correction
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: PPM
    start: '-30'
    step: '0.1'
    stop: '30'
    value: '0'
    widget: counter
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: IF gain
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: lna_enable
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,2,1,1
    label: LNA
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: lp_taps_if
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '2800'
    low_cutoff_freq: '200'
    samp_rate: samp_rate / decimation
    type: complex_band_pass
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: lp_taps_rf
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '75000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '25000'
    win: window.WIN_HAMMING
  states: {}
- name: offset
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: tune
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,4,1,3
    label: Tune (kHz)
    start: '80'
    step: '0.01'
    stop: '120'
    value: '100'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,6,1,1
    label: TX gain
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
  states: {}
- name: tx_text
  id: variable_qtgui_entry
  parameters:
    gui_hint: 1,0,1,4
    label: CW to send
    type: string
    value: ''
  states: {}
- name: audio_out
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '8000'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 4,0,1,4
    int_max: '0'
    int_min: '-120'
    showports: 'True'
    type: float
  states: {}
- name: cx_to_real
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: offset
    decim: decimation
    samp_rate: samp_rate
    taps: lp_taps_rf
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-100000 + tune * 1000 - 700'
    decim: '25'
    samp_rate: samp_rate / decimation
    taps: lp_taps_if
    type: ccc
  states: {}
- name: if_waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '100000'
    fftsize: '2048'
    gui_hint: 3,0,1,7
    int_max: '0'
    int_min: '-120'
    showports: 'True'
    type: complex
  states: {}
- name: interpolator
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '6'
    taps: ''
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,4,1,3
    legend: 'False'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: lna_enable
    center_freq: (band * 1e6 + 100000 - offset) * (1 + correction*1e-6)
    gain: if_gain
    samp_rate: samp_rate
    type: fc32
    vga: bb_gain
  states: {}
- name: volume_mult
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}

connections:
- [cx_to_real, '0', audio_waterfall, '0']
- [cx_to_real, '0', interpolator, '0']
- [freq_xlating_fft_filter_ccc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', if_waterfall, '0']
- [freq_xlating_fir_filter_xxx_0, '0', cx_to_real, '0']
- [interpolator, '0', volume_mult, '0']
- [soapy_hackrf_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [volume_mult, '0', audio_out, '0']
- [volume_mult, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
